# Keil uVision project QX82022-TYH-A34-JD6628.uvprojx, settings and files
target PD67W (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F032x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.19
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: QX82022-TYH-A34- +hex
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F032x8
  c misc: --diag_suppress=1295,381
  c include: ..\Inc;..\Drivers\BSP\PY32F032xx_Start_Kit;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F032\Include;..\Drivers\PY32F032_HAL_Driver\Inc;..\User;..\include;..\flythings\ui;..\flyport;..\flyport\graphics;..\..\UI_HYH_135x240\src;..\SEGGER_RTT;..\flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f032xx.s
    ../Src/: system_py32f032.c
  group Application/User
    ../Src/: main.c py32f032_hal_msp.c py32f032_it.c
  group User
    ../User/: SysClock.c devmodule.c ring.c usermain.c SerialFlash.c uartupgradedev.c display.c key.c pm.c iic_soft.c st7735.c fonts.c sw2302.c InnerResource.c ntc.c husb385a.c flash.c uart.c SP86xx_uart.c jd6628.c i2c_hal.c device_model.c
    ../SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group ui
    ../../UI_HYH_135X240/src/logic/: power.c powerup.c temp.c
    ../../UI_HYH_135X240/src/: ui_context.c
  group flyport
    ../flyport/event/: SDL_event.c
    ../flyport/graphics/: video.c
    ../flyport/timer/: SDL_timer.c
    ../flythings/: FlyThingsLib_F032.lib
  group flash
    ../flash/: flash.c tinyFlash.c tinyFlash_port.c README.md
  group Drivers/PY32F032_HAL_Driver
    ../Drivers/PY32F032_HAL_Driver/Src/: py32f032_hal.c py32f032_hal_cortex.c py32f032_hal_rcc.c py32f032_hal_rcc_ex.c py32f032_hal_pwr.c py32f032_hal_pwr_ex.c py32f032_hal_gpio.c py32f032_hal_dma.c py32f032_hal_uart.c py32f032_hal_spi.c py32f032_hal_sci.c py32f032_hal_sci_ex.c py32f032_hal_adc.c py32f032_hal_adc_ex.c py32f032_hal_tim.c py32f032_hal_tim_ex.c py32f032_hal_i2c.c py32f032_hal_i2c_ex.c py32f032_hal_flash.c py32f032_hal_flash_ex.c
software components: CMSIS:CORE 5.6.0

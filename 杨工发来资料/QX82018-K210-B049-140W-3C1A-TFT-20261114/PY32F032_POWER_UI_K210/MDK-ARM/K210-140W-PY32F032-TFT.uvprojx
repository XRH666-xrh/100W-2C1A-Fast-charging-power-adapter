# Keil uVision project K210-140W-PY32F032-TFT.uvprojx, settings and files
target EN_CN (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: PY32F032x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.19
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: QX82018-K210-B049-EN-CN +hex
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F032x8
  c misc: --diag_suppress=1295,381
  c include: ..\Inc;..\Drivers\BSP\PY32F032xx_Start_Kit;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\PY32F032\Include;..\Drivers\PY32F032_HAL_Driver\Inc;..\User;..\include;..\flythings\ui;..\flyport;..\flyport\graphics;..\..\UI_N133_240X240_K210\src;..\SEGGER_RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ./: startup_py32f032xx.s
    ../Src/: system_py32f032.c
  group Application/User
    ../Src/: main.c py32f032_hal_msp.c py32f032_it.c
  group User
    ../User/: SysClock.c devmodule.c ring.c usermain.c SerialFlash.c uartupgradedev.c display.c key.c pm.c iic_soft.c SP8610.h SP8630_SP8612.h SP8650.h flash.c uart.c SP86xx_uart.c
    ../SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group ui
    ../../UI_N133_240X240_K210/src/: ui_context.c
    ../../UI_N133_240X240_K210/src/logic/: P1.c P2.c P3.c P4.c poweroff.c powerup.c run.c
  group flyport
    ../flyport/event/: SDL_event.c
    ../flyport/graphics/: video.c
    ../flyport/timer/: SDL_timer.c
    ../flythings/: FlyThingsLib_F032.lib
  group Drivers/PY32F032_HAL_Driver
    ../Drivers/PY32F032_HAL_Driver/Src/: py32f032_hal.c py32f032_hal_cortex.c py32f032_hal_rcc.c py32f032_hal_rcc_ex.c py32f032_hal_pwr.c py32f032_hal_pwr_ex.c py32f032_hal_gpio.c py32f032_hal_dma.c py32f032_hal_uart.c py32f032_hal_spi.c py32f032_hal_sci.c py32f032_hal_sci_ex.c
target EN (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32F032x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.19
  cpu: as above
  output: QX82018-K210-B049-EN +hex
  AfterMake: fromelf --text -a -c -o "$L@L.asm" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F032x8,EN_ONLY
  c misc: --diag_suppress=1295,381
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.6.0
